# Autodesk Inventor part: Fig817-PF_18MM
## iProperties
Created: 2012-02
Part Number: Fig817-PF_18MM
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
